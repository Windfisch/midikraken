File: schem/din5_pcb/din5_pcb.sch (KiCad schematic (older format))
At the start: 76 parts, among them J1 Conn_01x03_Male, J101 DIN-5_180degree, J102 DIN-5_180degree, J103 DIN-5_180degree, J104 DIN-5_180degree, J111 do not equip, J112 do not equip, J113 do not equip, J114 do not equip, J2 Conn_02x03_Odd_Even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

Commit message: Final schematic fixes
Connections:
- net +3V3: now also J8.2 (Pin_2)
- net +5V: no longer J8.2 (Pin_2)
- no-connect marks 49 -> 53
Other:
- note added: "todo (pcb): add jlcjlc marker to both"
- note added: "todo (pcb): are the connectors oriented correctly?\ntodo (pcb): do the connector plugs fit?"
- note added: "todo (pcb): mark pin 1 on connectors"
- note added: "todo (pcb): move display up a little?"
- note added: "todo: is BLK cheap to connect?"
Changed lines of the file:
@@
 Wire Wire Line
 	8675 4875 8675 4650
-$Comp
-L power:+5V #PWR05
-U 1 1 6106B5E8
-P 8675 4650
-F 0 "#PWR05" H 8675 4500 50  0001 C CNN
-F 1 "+5V" H 8525 4725 50  0000 C CNN
-F 2 "" H 8675 4650 50  0001 C CNN
-F 3 "" H 8675 4650 50  0001 C CNN
-	1    8675 4650
-	1    0    0    -1
-$EndComp
 Wire Wire Line
 	2300 2525 2600 2525
@@
 NoConn ~ 525  6925
 NoConn ~ 1125 6925
+NoConn ~ 800  1125
+NoConn ~ 825  5300
+NoConn ~ 825  7225
+NoConn ~ 9400 4600
+Text Notes 5975 -375 0    50   ~ 0
+todo: is BLK cheap to connect?
+$Comp
+L power:+3V3 #PWR?
+U 1 1 60E24BA6
+P 8675 4650
+F 0 "#PWR?" H 8675 4500 50  0001 C CNN
+F 1 "+3V3" H 8550 4800 50  0000 C CNN
+F 2 "" H 8675 4650 50  0001 C CNN
+F 3 "" H 8675 4650 50  0001 C CNN
+	1    8675 4650
+	1    0    0    -1
+$EndComp
+Text Notes 5975 -575 0    50   ~ 0
+todo (pcb): add jlcjlc marker to both
+Text Notes 5975 -475 0    50   ~ 0
+todo (pcb): move display up a little?
+Text Notes 5975 -850 0    50   ~ 0
+todo (pcb): mark pin 1 on connectors
+Text Notes 5975 -675 0    50   ~ 0
+todo (pcb): are the connectors oriented correctly?\ntodo (pcb): do the connector plugs fit?
 $EndSCHEMATC
