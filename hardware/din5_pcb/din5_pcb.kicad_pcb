# Repository Windfisch/midikraken

File README.md:

Midikraken
==========

An open-source, open-hardware MIDI-USB-interface supporting up to 16
(and maybe beyond?) MIDI ports. The hardware is based on a STM32F103
*"blue pill"* board which can be cheaply sourced from your favourite chinese
seller ([note about quality differences](https://github.com/Windfisch/analog-synth/blob/master/bluepill.md)),
plus other garden variety components such as HC2630 opto couplers (that's just
two 6N137 in one package), shift registers, some LEDs and resistors.

Apart from being a MIDI-USB-interface, Midikraken is a feature-packed MIDI
router supporting separate clock and note event routing, clock division.
Future features may include split-keyboard routing, clock generation or even a
hardware arpeggiator.

Below you will find a technical overview. [A user manual is available here](documentation/README.md).

Releases
--------

Find the latest firmware upgrade packages [on the releases page](https://github.com/Windfisch/midikraken/releases).
You only need an USB cable, instructions for Linux and Windows are included.

The schematics and board layout files are [on a separate page](https://github.com/Windfisch/midikraken-hardware/releases).
Hardware and firmware are versioned separately, their numbers do not match.

Hardware
--------

Midikraken consists of two different PCBs that can be stacked (almost)
arbitrarily: [The DIN board](hardware/din5_pcb) has four traditional MIDI
in/out port pairs, and can house the master microcontroller.

[The TRS board](hardware/trs_pcb) gives you eight TRS MIDI pairs that support
both TRS-A and TRS-B. (Inputs are automatic, outputs need to be configured
in software). It can not house the microcontroller and thus cannot be used
without a DIN board.

The boards can be chained using their master/slave connectors and are
stackable using M3 screws / spacers. Currently, the firmware must be
adapted and recompiled according to the stack configuration. Currently,
a maximum of 16 port pairs is supported.

For information on the hardware, the revision history and errata, see [the hardware documentation](hardware/README.md).
A [build guide](documentation/build_guide/README.md) for rev01 and rev02 is available.

Firmware
--------

The firmware is written in Rust and is released under the GPLv3 license.

Since the STM32F103 only offers 3 hardware UARTs, we need to emulate the UART
protocol in software. For this, a timer interrupt oversamples the UART input pins
with thrice the baudrate in order to always read a stable bit at a non-edge.
(Guaranteed 1/3 * bit time distance from any edge, so the signal should be quite
stable until then.)

[Benchmarks show](firmware/benchmark/README.md) that this can be done fast
enough for up to 16 software UARTs (and likely even more), while leaving
plenty of cpu cycles (25% for 16 UARTs) free for other work.

Further information about the firmware itself can be found
[in the firmware documentation](firmware/README.md).

License
-------

The software in the [firmware](firmware) directory can be redistributed
and/or modified under the terms of the
[GNU General Public License Version 3](gpl3.txt). Note this does not apply
to the [bootloader](firmware/sboot/sboot_stm32) which is under its own
license.

The hardware designs in the [hardware](hardware) directory, excluding
[hardware/lib/3d](hardware/lib/3d) to which own conditions apply, can be
licensed under the terms of the [CERN OHL Version 2 license](cern_ohl_s_v2.txt).
This specifically includes (but is not limited to) schematics, PCB designs and
gerber files.

Contributing
------------

I am happy about contributions, just open a pull request!

**Note:** Even though Midikraken is licensed under GPLv3 and OHL-S-v2 (the exact
versions), any contributions / pull requests must be licensed under the
"GPLv3 *or any later version*" or "OHL-S-v2 *or any later version*", respectively.
This is because on the one hand, I want to be able to update the project to new
versions of these licenses, but on the other hand, I don't like licensing my work
under a license (e.g. the hypothetical GPLv4) that I haven't even read yet. If such
a license is released, I will likely adopt it after revising it.

## KiCad design hardware/din5_pcb/din5_pcb.kicad_pcb

File hardware/README.md (part):

Midikraken hardware
===================

This page describes the hardware itself. A [build manual is available here](../documentation/build_guide/README.md).

Midikraken boards are meant to be **stacked** using M3 spacers and screws.
In such a setup, one "master" exists that holds the microcontroller with
the USB port, and zero or multiple "slaves" are daisy-chained with their
upstream ("from master") or downstream ("to slave") ports.

The photo shows an (almost) fully equipped Midikraken including:

- 1 DIN connector board (the large MIDI connectors).
- 1 TRS connector board (MIDI via headphone jacks).
- The main microcontroller
- The UI consisting of a display and a rotary encoder.

Midikraken boards can be stacked almost arbitrarily; the only limit is
(currently) a maximum of 16 MIDI in/out port pairs.

Two board types are available:
- The DIN board with four DIN MIDI inputs and four outputs
- and the TRS board with eight TRS inputs and eight outputs.

DIN boards may or may not house the main microcontroller, so every stack needs
one. Note that the DIN board can be used to house only the microcontroller, if
desired. No actual MIDI ports need to be equipped, making a TRS-only stack
possible.

The TRS board supports both TRS-MIDI-A and -B (where roles of tip and ring
are swapped).

Note that while it would be possible to design boards with
only inputs or only outputs, the current boards do *not* support switching
an input port to output mode or vice versa. If desired, however, inputs
can be left unmounted; in this case, the appropriate LEDs and opto-couplers
can be left out, too.

Board variants
--------------

Both boards can be built in different variants. For the DIN board, the options
include:

- It can either house the **microcontroller** *(A1)* or act as a **slave** *(A2).
- It can hold **angled MIDI connectors** (*B1*, the default), or **not have any connectors** *(B2)*.
  (This is useful when used as user interface board only). *(Additionally, there
  is a somewhat hacky way to mount upward-facing MIDI connectors to it for use
  in Eurorack setups, but that's dirty and untested.)*
- If the board is configured as a master, it can or can not have a **user
  interface** *(C)* consisting of a display and a rotary knob with a push button.
- If the board holds a microcontroller, it can support chaining more boards to it *(D1)*,
  or save some components at the cost of losing the chaining ability *(D2)*. (*not
  recommended*).
- In this case, MIDI can be driven with 5V *(E1)* or with 3.3V *(E2, saves another chip, 
  not recommended)*.
- As a the buffer U1, a 74HCT245 *(F1)* or 74HCT541 *(F2)* can be used.

For the TRS board, two options are available:
- Either 8 in/out port pairs are mounted *(X1)*
- or only one side is equipped with only 4 in/out pairs *(X2)*
- **Angled TRS jacks** (PJ-324) *(Y1)* or **upright** TRS jacks *(Y2)* can be used.

The following components need or need not be mounted on the PCB:
- *(A1)*: mount A1, J1, U1; leave J3 unmounted.
- *(A2)*: mount J3, leave A1, J1, U1 unmounted.
- *(B1)*: mount J10x and J20x, U101, U102, U2, U3 and Dxxx.
- *(B2)*: do not mount the components from *(B1)*, instead run a copper wire across *TODO*.
- *(C)*: mount or do not mount J8 and SW1.
- *(D2)*: Close JP1-4, and close JP5-8 according to your selection in *(E)*.
- *(E2)*: Do not equip U1.
- *(F)*: Configure JP9 accordingly.
- *(X2)*: Close JP102 and do not mount Jx05-Jx08, and all LEDs and resistors on this side.
 Also do not mount U205-U208.
- *(Y)*: Solder in what is needed, the PCB can hold both.

**Note:** While this sounds complicated, in the recommended default configuration which is reflected
by the BOM and schematics, only JP9 needs to be closed to select the IC type used in U1. All other
solder bridges are left open and no deviations from the schematic need to be made, except for *(A)*.

Currently, two different hardware revisions exist. They are described here from most recent to
oldest.

Revision 01
-----------

### Bill of material

[din5_pcb/bom.html](https://htmlpreview.github.io/?https://github.com/Windfisch/midikraken/blob/master/hardware/din5_pcb/bom.html),
[interactive BOM](https://htmlpreview.github.io/?https://github.com/Windfisch/midikraken/blob/master/hardware/din5_pcb/ibom.html)

[trs_pcb/bom.html](https://htmlpreview.github.io/?https://github.com/Windfisch/midikraken/blob/master/hardware/trs_pcb/bom.html),
[interactive BOM](https://htmlpreview.github.io/?https://github.com/Windfisch/midikraken/blob/master/hardware/trs_pcb/ibom.html)

### Errata

During powerup, the MIDI ports send garbage bits. To fix this,
you need to disconnect the 74HC595s' *output enable* pins from GND
using a sharp knife (and some wire to reconnect all GNDs that should stay
connected), and connecting them like this instead:

```
+5V --- Capacitor 10µF --- OE pin --- Resistor 10k --- GND
```

This delays the output enable enough such that the shift registers can
be filled with proper data after the microcontroller has booted up.

The exact fixing procedure is described in [this document](../documentation/rev01_fix/README.md).

### Eurorack compatibility

Please note that Midikraken was designed as a standalone adapter box. However,
where possible, efforts were made to make Midikraken as Eurorack compatible as
possible:

- The PCBs are 110mm in height, fitting tightly into any Eurorack setup.
- The boards are prepared for upright connectors. This is sort of hacky, but it
  might work. The TRS board can hold PJ392 sockets that are usually meant to
  have wires soldered to their legs. The DIN board can hold DIN sockets similar
  to the NYS325, with a hack: The outermost two solder tail must be removed, and
  the remaining three must be bent so that they fit into the PCB.
- Alternatively, any socket can be used and wires can be soldered to the PCB.

Enclosure
---------

Midikraken can either be built half-open as shown in the photo above, or can be
protected from dust and metallic parts with a 3d-printed enclosure.  The
enclosures reflect Midikraken's modular nature and itself can be stacked onto
each other. Currently, three enclosure modules exist:

- The [**display shell**](cad/display_shell.FCStd) which is put on top of the DIN5
  PCB and holds the display.  It terminates the Midikraken stack to the upper
  side.
- The [**DIN5 shell**](cad/din5_shell.FCStd) which is put on the opposite side of
  the DIN5 PCB and covers the MIDI ports, leaving cutouts for the LEDs and the
  USB port.
- The [**TRS shell**](cad/trs_back_shell.FCStd) which covers the ports of the TRS
  PCB and terminates the Midikraken stack.
- Additionally, the [**display top plate**](frontplate) and [**back plate**](backplate)
  are alternatives to the display shell and should be used in the half-open,
  caseless configuration to support the display and protect the circuitry.

The enclosure light guides that cover the LED holes and make it easier to see
the LEDs from an angle. These guides are to be printed with transparent material
and are snapped in from the inside.
(DIN5 needs 4 of [these](cad/din5_lightguide.FCStd) and TRS needs 8 of [these](cad/trs_lightguide.FCStd))

Yet to be done:

- A **terminating DIN5 shell** with a bottom plate for builds without a TRS shell.
- A **non-terminating TRS shell** for builds that use more than one TRS board.
  Note that currently, the firmware only supports a maximum of 16 MIDI ports, which
  rules out a two-TRS-board-solution for now.

Ghettokraken on perfboard
-------------------------

Schematics for the first prototype board were created with KiCAD and are
located in [perfboard](perfboard).

A 3D-printed enclosure (which needs some adjustments to fit well) was
designed in FreeCAD and resides in [perfboard/cad/](perfboard/cad/).
The enclose provides the DIN ports with additional stability which the
usual perfboards lack.

**Note**: You need to use the firmware from 7072a0c6eb or earlier due
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
Board: 2 copper layers, 56.0 x 110.0 mm, 82 parts (47 on the bottom side), 70 nets.

Parts:
A1: BluePill; BLUEPILL-blackpill
C101, C102: 100n; C_0805_2012Metric
D101, D102, D103, D104: LED; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
D201, D202, D203, D204: yellow; LED_D3.0mm_Horizontal_O3.81mm_Z6.0mm
J1: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Horizontal
J2, J3: Conn_02x03_Odd_Even; IDC-Header_2x03_P2.54mm_Vertical
J4, J5: USB_B_Micro; USB_Micro-B_Wuerth_629105150521
J6, J7: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Vertical
J8: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
J101, J102, J103, J104, J201, J202, J203, J204: DIN-5_180degree; DIN5
J111, J112, J113, J114, J211, J212, J213, J214: do not equip; din5-frickel
JP1, JP2, JP3, JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP5, JP6, JP7, JP8: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP9, JP14: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
R1: R; R_0805_2012Metric
R101, R102, R103, R104, R107, R108, R111, R112, R205, R206, R207, R208, R209, R210, R211, R212: 220; R_0805_2012Metric
R105, R106, R109, R110, R201, R202, R203, R204: 1k; R_0805_2012Metric
SW1: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
U1: 74HCT245; DIP-20_W7.62mm
U2: 74HC595; DIP-16_W7.62mm
U3: 74HC165; DIP-16_W7.62mm
U101, U102: HCPL-2630; DIP-8_W7.62mm
hole1, hole2, hole3, hole4: MountingHole_3.2mm_M3_DIN965
oh: OSHW-Logo2_9.8x8mm_SilkScreen
wf: LOGO; windfisch_smaller

Connections:
+3V3: A1.3V3, J8.2, JP14.3
+5V: A1.5V, JP14.1
GND: A1.G, C101.1, C102.1, J1.3, J2.6, J3.6, J4.5, J5.5, J6.3, J7.2, J7.4, J8.1, J201.2, J202.2, J203.2, J204.2, J211.2, J212.2, J213.2, J214.2, JP9.3, R1.1, SW1.C, SW1.S2, U1.9, U1.10, U1.19, U2.8, U2.13, U3.3, U3.4, U3.5, U3.6, U3.8, U3.15, U101.5, U102.5
MIDI_MISO_CHAIN: J2.2, R1.2, U3.10
MIDI_MOSI_CHAIN: J2.3, U2.9
MISO_MIDI: A1.PB4, J3.2, U3.9
MOSI_MIDI_5: J3.3, U1.18, U2.14
unnamed: A1.PA9, J1.2
unnamed: A1.PA10, J1.1
unnamed: A1.PB3, U1.3
unnamed: A1.PB5, U1.2
unnamed: A1.PB12, JP4.1
unnamed: A1.PB14, JP2.1
unnamed: A1.PC14, U1.4
unnamed: D101.1, R107.1
unnamed: D102.1, R111.1
unnamed: D103.1, R108.1
unnamed: D104.1, R112.1
unnamed: D201.2, R201.2
unnamed: D202.2, R202.2
unnamed: D203.2, R203.2
unnamed: D204.2, R204.2
unnamed: J101.4, J111.4, R101.2
unnamed: J101.5, J111.5, U101.2
unnamed: J102.4, J112.4, R102.2
unnamed: J102.5, J112.5, U101.3
unnamed: J103.4, J113.4, R103.2
unnamed: J103.5, J113.5, U102.2
unnamed: J104.4, J114.4, R104.2
unnamed: J104.5, J114.5, U102.3
unnamed: J201.4, J211.4, R209.1
unnamed: J201.5, J211.5, R205.1
unnamed: J202.4, J212.4, R210.1
unnamed: J202.5, J212.5, R206.1
unnamed: J203.4, J213.4, R211.1
unnamed: J203.5, J213.5, R207.1
unnamed: J204.4, J214.4, R212.1
unnamed: J204.5, J214.5, R208.1
unnamed: JP5.3, U1.12
unnamed: JP6.3, U1.13
unnamed: JP7.3, U1.14
unnamed: JP8.3, U1.15
unnamed: JP9.2, U1.1
unnamed: R101.1, U101.1
unnamed: R102.1, U101.4
unnamed: R103.1, U102.1
unnamed: R104.1, U102.4
PA1: A1.PA1, J8.5
PA2: A1.PA2, J8.6
PB6: A1.PB6, JP5.1, SW1.A, U1.8
PB7: A1.PB7, JP6.1, SW1.B, U1.7
PB8: A1.PB8, JP7.1, U1.6
PB9: A1.PB9, JP8.1, U1.5
PB13: A1.PB13, J8.3, JP3.1
PB15: A1.PB15, J8.4, JP1.1
PC15: A1.PC15, SW1.S1
SCK_MIDI_5: J2.5, J3.5, U1.17, U2.11, U3.2
STROBE_MIDI_5: J2.4, J3.4, U1.16, U2.12, U3.1
USB_DM: A1.PA11, J4.2, J6.4
USB_DP: A1.PA12, J4.3, J6.2
USB_ID: A1.PA8, J4.4
VCC: C101.2, C102.2, D101.2, D102.2, D103.2, D104.2, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J7.3, JP9.1, JP14.2, R105.1, R106.1, R109.1, R110.1, R201.1, R202.1, R203.1, R204.1, R209.2, R210.2, R211.2, R212.2, U1.20, U2.10, U2.16, U3.16, U101.8, U102.8
in0: JP4.2, R105.2, R107.2, U3.11, U101.7
in1: JP3.2, R109.2, R111.2, U3.12, U101.6
in2: JP2.2, R106.2, R108.2, U3.13, U102.7
in3: JP1.2, R110.2, R112.2, U3.14, U102.6
out0: D201.1, JP5.2, R205.2, U2.15
out1: D202.1, JP6.2, R206.2, U2.1
out2: D203.1, JP7.2, R207.2, U2.2
out3: D204.1, JP8.2, R208.2, U2.3

## KiCad design hardware/trs_pcb/pcb.kicad_pcb

Board: 2 copper layers, 56.0 x 110.0 mm, 125 parts (91 on the bottom side), 97 nets.

Parts:
C201, C202, C203, C204, C205, C206, C207, C208: 100n; C_0805_2012Metric
D201, D202, D203, D204, D205, D206, D207, D208: LED; LED_D3.0mm_Horizontal_O6.35mm_Z2.0mm
D301, D302, D303, D304, D309, D310, D311, D312: yellow; LED_D3.0mm_Horizontal_O6.35mm_Z2.0mm
D305, D306, D307, D308, D313, D314, D315, D316: green; LED_D3.0mm_Horizontal_O6.35mm_Z2.0mm
J101, J102: Conn_02x03_Odd_Even; IDC-Header_2x03_P2.54mm_Vertical
J201, J202, J203, J204, J205, J206, J207, J208, J301, J302, J303, J304, J305, J306, J307, J308: AudioJack3; Jack_3.5mm_combo_ledino_upright
JP102: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R101: R; R_0805_2012Metric
R201, R202, R203, R204, R209, R210, R211, R212, R213, R214, R215, R216, R221, R222, R223, R224, R309, R310, R311, R312, R313, R314, R315, R316, R325, R326, R327, R328, R329, R330, R331, R332: 220; R_0805_2012Metric
R205, R206, R207, R208, R217, R218, R219, R220, R301, R302, R303, R304, R305, R306, R307, R308, R317, R318, R319, R320, R321, R322, R323, R324: 1k; R_0805_2012Metric
U102: 74HC165; DIP-16_W7.62mm
U103, U104: 74HC595; DIP-16_W7.62mm
U201, U202, U203, U204, U205, U206, U207, U208: HCPL-2630; DIP-8_W7.62mm
hole1, hole2, hole3, hole4: MountingHole_3.2mm_M3_DIN965
oshw: OSHW-Logo2_9.8x8mm_SilkScreen
wf: LOGO; windfisch_smaller

Connections:
+5V: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, D201.2, D202.2, D203.2, D204.2, D205.2, D206.2, D207.2, D208.2, J101.1, J102.1, R205.1, R206.1, R207.1, R208.1, R217.1, R218.1, R219.1, R220.1, R301.1, R302.1, R303.1, R304.1, R305.1, R306.1, R307.1, R308.1, R317.1, R318.1, R319.1, R320.1, R321.1, R322.1, R323.1, R324.1, U102.16, U103.10, U103.16, U104.10, U104.16, U201.8, U202.8, U203.8, U204.8, U205.8, U206.8, U207.8, U208.8
/8x TRS Midi input/in0: R205.2, R209.2, U102.11, U201.6, U201.7
/8x TRS Midi input/in1: R206.2, R210.2, U102.12, U202.6, U202.7
/8x TRS Midi input/in2: R207.2, R211.2, U102.13, U203.6, U203.7
/8x TRS Midi input/in3: R208.2, R212.2, U102.14, U204.6, U204.7
/8x TRS Midi input/in4: R217.2, R221.2, U102.3, U205.6, U205.7
/8x TRS Midi input/in5: R218.2, R222.2, U102.4, U206.6, U206.7
/8x TRS Midi input/in6: R219.2, R223.2, U102.5, U207.6, U207.7
/8x TRS Midi input/in7: R220.2, R224.2, U102.6, U208.6, U208.7
/8x TRS Midi output/out0a: D301.1, R309.2, U103.15
/8x TRS Midi output/out0b: D305.1, R310.2, U103.4
/8x TRS Midi output/out1a: D302.1, R311.2, U103.1
/8x TRS Midi output/out1b: D306.1, R312.2, U103.5
/8x TRS Midi output/out2a: D303.1, R313.2, U103.2
/8x TRS Midi output/out2b: D307.1, R314.2, U103.6
/8x TRS Midi output/out3a: D304.1, R315.2, U103.3
/8x TRS Midi output/out3b: D308.1, R316.2, U103.7
/8x TRS Midi output/out4a: D309.1, R325.2, U104.15
/8x TRS Midi output/out4b: D313.1, R326.2, U104.4
/8x TRS Midi output/out5a: D310.1, R327.2, U104.1
/8x TRS Midi output/out5b: D314.1, R328.2, U104.5
/8x TRS Midi output/out6a: D311.1, R329.2, U104.2
/8x TRS Midi output/out6b: D315.1, R330.2, U104.6
/8x TRS Midi output/out7a: D312.1, R331.2, U104.3
/8x TRS Midi output/out7b: D316.1, R332.2, U104.7
GND: C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, J101.6, J102.6, J301.S, J302.S, J303.S, J304.S, J305.S, J306.S, J307.S, J308.S, R101.1, U102.8, U102.15, U103.8, U103.13, U104.8, U104.13, U201.5, U202.5, U203.5, U204.5, U205.5, U206.5, U207.5, U208.5
MIDI_MISO_CHAIN: J101.2, R101.2, U102.10
MIDI_MOSI_CHAIN: J101.3, JP102.1, U104.9
MISO_MIDI: J102.2, U102.9
MOSI_MIDI_5: J102.3, U103.14
unnamed: D201.1, R209.1
unnamed: D202.1, R210.1
unnamed: D203.1, R211.1
unnamed: D204.1, R212.1
unnamed: D205.1, R221.1
unnamed: D206.1, R222.1
unnamed: D207.1, R223.1
unnamed: D208.1, R224.1
unnamed: D301.2, R301.2
unnamed: D302.2, R302.2
unnamed: D303.2, R303.2
unnamed: D304.2, R304.2
unnamed: D305.2, R305.2
unnamed: D306.2, R306.2
unnamed: D307.2, R307.2
unnamed: D308.2, R308.2
unnamed: D309.2, R317.2
unnamed: D310.2, R318.2
unnamed: D311.2, R319.2
unnamed: D312.2, R320.2
unnamed: D313.2, R321.2
unnamed: D314.2, R322.2
unnamed: D315.2, R323.2
unnamed: D316.2, R324.2
unnamed: J201.R, R201.2
unnamed: J201.T, U201.2, U201.4
unnamed: J202.R, R202.2
unnamed: J202.T, U202.2, U202.4
unnamed: J203.R, R203.2
unnamed: J203.T, U203.2, U203.4
unnamed: J204.R, R204.2
unnamed: J204.T, U204.2, U204.4
unnamed: J205.R, R213.2
unnamed: J205.T, U205.2, U205.4
unnamed: J206.R, R214.2
unnamed: J206.T, U206.2, U206.4
unnamed: J207.R, R215.2
unnamed: J207.T, U207.2, U207.4
unnamed: J208.R, R216.2
unnamed: J208.T, U208.2, U208.4
unnamed: J301.R, R309.1
unnamed: J301.T, R310.1
unnamed: J302.R, R311.1
unnamed: J302.T, R312.1
unnamed: J303.R, R313.1
unnamed: J303.T, R314.1
unnamed: J304.R, R315.1
unnamed: J304.T, R316.1
unnamed: J305.R, R325.1
unnamed: J305.T, R326.1
unnamed: J306.R, R327.1
unnamed: J306.T, R328.1
unnamed: J307.R, R329.1
unnamed: J307.T, R330.1
unnamed: J308.R, R331.1
unnamed: J308.T, R332.1
unnamed: JP102.2, U103.9, U104.14
unnamed: R201.1, U201.1, U201.3
unnamed: R202.1, U202.1, U202.3
unnamed: R203.1, U203.1, U203.3
unnamed: R204.1, U204.1, U204.3
unnamed: R213.1, U205.1, U205.3
unnamed: R214.1, U206.1, U206.3
unnamed: R215.1, U207.1, U207.3
unnamed: R216.1, U208.1, U208.3
SCK_MIDI_5: J101.5, J102.5, U102.2, U103.11, U104.11
STROBE_MIDI_5: J101.4, J102.4, U102.1, U103.12, U104.12

## KiCad design schem/perfboard/perfboard.kicad_pcb

Parts:
A1: BluePill; BLUEPILL
C1, C2, C3, C4: 100n; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_D5.0mm
J1, J2, J3, J4, J5, J6, J7, J8: DIN-5; DIN5
R1, R7, R13, R19: 220; R_0805_2012Metric
R2, R8, R14, R20: 47; R_0805_2012Metric
R3, R5, R9, R11, R15, R17, R21, R23: 100; R_0805_2012Metric
R4, R10, R16, R22: 10k; R_0805_2012Metric
R6, R12, R18, R24: 10; R_0805_2012Metric
U1, U2, U3, U4: 6N137; DIP-8_W7.62mm

Connections:
+3V3: A1.3V3 (3.3V), D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), R2.1, R4.1, R8.1, R10.1, R14.1, R16.1, R20.1, R22.1
+5V: A1.5V, C1.1, C2.1, C3.1, C4.1, U1.8 (VCC), U2.8 (VCC), U3.8 (VCC), U4.8 (VCC)
GND: A1.G (GND), C1.2, C2.2, C3.2, C4.2, J2.2, J4.2, J6.2, J8.2, U1.5 (GND), U2.5 (GND), U3.5 (GND), U4.5 (GND)
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R3.1
unnamed: D3.1 (K), R11.1
unnamed: D4.1 (K), R9.1
unnamed: D5.1 (K), R17.1
unnamed: D6.1 (K), R15.1
unnamed: D7.1 (K), R23.1
unnamed: D8.1 (K), R21.1
unnamed: J1.4, R1.2
unnamed: J1.5, U1.3 (C)
unnamed: J2.4, R2.2
unnamed: J2.5, R6.2
unnamed: J3.4, R7.2
unnamed: J3.5, U2.3 (C)
unnamed: J4.4, R8.2
unnamed: J4.5, R12.2
unnamed: J5.4, R13.2
unnamed: J5.5, U3.3 (C)
unnamed: J6.4, R14.2
unnamed: J6.5, R18.2
unnamed: J7.4, R19.2
unnamed: J7.5, U4.3 (C)
unnamed: J8.4, R20.2
unnamed: J8.5, R24.2
unnamed: R1.1, U1.2 (A)
unnamed: R7.1, U2.2 (A)
unnamed: R13.1, U3.2 (A)
unnamed: R19.1, U4.2 (A)
PA0: A1.PA0, R3.2, R6.1
PA1: A1.PA1, R9.2, R12.1
PA2: A1.PA2, R15.2, R18.1
PA3: A1.PA3, R21.2, R24.1
PB5: A1.PB5, R4.2, R5.2, U1.6 (VO)
PB6: A1.PB6, R10.2, R11.2, U2.6 (VO)
PB7: A1.PB7, R16.2, R17.2, U3.6 (VO)
PB8: A1.PB8, R22.2, R23.2, U4.6 (VO)

Board: 2 copper layers, 50.8 x 101.6 mm, 49 parts (0 on the bottom side), 39 nets.

## Commit log (part)

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2021-03-10 Timer test
2021-03-11 receiver code
2021-03-13 It works \o/
2021-03-13 README.md
2021-03-14 improve jitter and test sending
2021-03-15 transmitting works \o/
2021-03-19 Add benchmarking code
2021-03-19 Add benchmarking test
2021-03-21 Print received bytes via ringbuffer
2021-03-21 Actually receiving MIDI :)
2021-03-21 First steps towards USB
2021-03-21 Changed usb-midi to submodule, no changes yet
2021-03-21 Create MIDI interface with 4 virtual cables
2021-03-22 Parse MIDI messages to USB format
2021-03-23 Move firmware crate to separate folder
2021-03-23 Factor out parse_midi, add tests, fix bugs
2021-03-25 USB sort-of seems to work; but hangs when sending too much data from the host
2021-03-25 Dirty fix for the freezing issue
2021-03-28 Fix usb and subrepo
2021-03-28 Use more GPIO pins
2021-03-30 Adapt firmware for perfboard prototype
2021-03-30 Add schematics for perfboard prototype
2021-03-30 First attempts with FreeCAD
2021-03-30 Finished midi port pockets
2021-03-30 Lid with holes
2021-03-30 Add hole for USB port
2021-03-31 Fix things, reduce top thickness
2021-03-31 Top drill holes
2021-03-31 Reduce top height
2021-03-31 Maybe almost finished?
2021-04-01 Fix cad model
2021-04-01 Final case CAD file
2021-04-03 Feature-gate benchmarking functionality
2021-04-03 Fix some warnings
2021-04-04 Factor out software_uart module
2021-04-05 Fixed benchmarking
2021-04-05 Fix benchmarking
2021-04-05 Cache send_buffers
2021-04-05 Cache recv_active
2021-04-05 Cache send_workbuf[i]
2021-04-08 Use generic arrays in SoftwareUart
2021-04-08 Add benchmarking tooling
2021-04-09 Change panic handler to write to UART1
2021-04-09 Fix lockup when receiving too many usb midi messages
2021-04-09 Replace mem::uninitialized with MaybeUninit
2021-04-09 Feature-gate debug printfs
2021-04-09 Fix device name
2021-04-09 Cleanup
2021-04-12 Consolidate subrepos and patches
2021-04-12 Fix UARTs not starting in their idle state upon boot
2021-04-12 README
2021-04-14 Prepare for bootloader, allow sysex to reset to dfu mode
2021-04-14 Update tooling for bootloader support
2021-04-14 More documentation and missing files
2021-04-15 Improve bootloader tooling, fix bugs
2021-04-15 Remove debug prints
2021-04-19 Nice performance graph
2021-04-19 explain the benchmarks and the optimizations
2021-04-19 Improve explanation
2021-04-19 benchmark++
2021-04-19 benchmark README++
2021-04-23 Actually use the c software uart in the interrupt handler (but not yet in other methods, this will not work)
2021-05-28 Update to mvirkkunen's descriptor writer proposal
2021-05-28 First attempts using SPI instead of GPIO
2021-05-28 Fix make tty baudrate
2021-05-28 SPI works \o/
2021-05-30 Fix makefile
2021-05-30 TRS-midi schematic
2021-05-30 First attempts at a PCB layout...
2021-05-31 rename trs pcb
2021-05-31 din5 pcb
2021-06-01 din5 pcb ++
2021-06-01 fp cache
2021-06-05 Add blackpill-compatible bluepill footprint
2021-06-05 Re-order parts on din5_pcb
2021-06-06 intermediate commit
2021-06-07 Come layout considerations
2021-06-07 din5 socket step file
2021-06-07 din 5 pin pcb finished. todo: autoroute
2021-06-08 Add janky 5-pin DIN upright connector
2021-06-08 Autorouted board, added 3d models
2021-06-08 final commit[tm] for the din 5 pcb
2021-06-08 place components on trs pcb
2021-06-09 autorouted
2021-06-11 Fix broken horizontal TRS jack footprint
2021-06-11 Increase bluepill hole size and reroute
2021-06-11 reroute one track
2021-06-11 Final schematic fixes
2021-06-11 use proper IDC footprints for connectors
2021-06-11 move connectors inwards, reroute
2021-06-12 Fix silkscreen, final touches
2021-07-11 Adjust the actual pins used in the schematic
2021-07-11 README++
2021-07-17 Set the shift registers to a defined state as quick as possible after startup
2021-07-17 Rework directory structure and add license information
2021-07-19 Fix schematic paths
2021-07-19 Add license hints to all hardware files
2021-07-20 Describe workaround for rev01 bug
2021-07-20 Add photo to readme
2021-07-20 Bill of material
2021-07-20 use htmlpreview.github.io
2021-07-20 Contributing
2021-08-01 Use pid.codes USB VID/PID
2021-08-04 Handle USB via ISR instead of looped polling again
    Implements #2.
2021-08-04 Increase debug UART baud rate
2021-08-04 ST7789 display support
2021-08-08 Wait between rebooting into bootloader mode and flashing
2021-08-08 Increase flash size
2021-08-08 Add knob support, fix bug from ISR transition
2021-08-08 Update to latest stm32f1xx-hal from git
2021-08-08 Remove unsafe code, upgrade to more permissive stm32f1xx-hal w.r.t pin configurations
2021-08-09 GUI POC
2021-08-10 Optimize only graphics for speed, the rest for size
2021-08-10 Basic MIDI routing
2021-08-10 Switch between event routing and clock routing menus
2021-08-10 GUI module
2021-08-14 Implement midi routing
2021-08-15 Improve display speed
    Addresses #42
2021-08-15 clean up a bit
2021-08-15 Clean up even more
    Fixes #42
2021-08-16 Reset to bootloader after panic
2021-08-16 Main menu and main screen
2021-08-17 Gui improvements
2021-08-17 Moved out performance-critical software UART code to other crate
    This is a hack to allow heavily optimizing the TIM2 ISR code (and all
    generics instantiated by it), while optimizing the rest of the code for
    size rather than for speed.
2021-09-03 display top enclosure
2021-09-03 DIN5 enclosure module (too thin)
2021-09-03 TRS enclosure (untested)
2021-09-03 Flat display plate
2021-09-04 Hopefully the final display cap model
2021-09-05 Made the display shell thinner, fixed sunken screws, tuned display holes
2021-09-05 Fix sunk screw shell
2021-09-05 Improve operation naming
2021-09-07 TRS back shell
2021-09-08 Parametrized trs cap
2021-09-08 add led holes
2021-09-08 finished back shell
2021-09-08 back shell ++
2021-09-08 add connector cutout
2021-09-12 fix back shell bug
2021-09-14 first din5 shell v2 attempts
2021-09-15 din5 case ++
2021-09-15 Add USB cutout
2021-09-16 din5_shell
2021-09-16 clean up enclosure cad files
2021-09-16 Improve wall stability for DIN shell
2021-09-16 Reduce din5 shell tolerances:
    - Reduce jack hole thickness from 3mm to 2.5mm
    - Increase middle clamp distance from 54.75mm to 55mm (which is the actual distance.)
    - Made stability beams thinner (3mm -> 2mm)
2021-09-17 Moved usb cutout down a bit
2021-09-17 deploy-to-board.sh
2021-09-19 Change LED resistors from 1k to 220 Ohm.
    Closes #61.
2021-09-19 Lightguides (to be printed in transparent)
2021-09-22 Add building.md
2021-09-30 Build guide
2021-10-02 Update build guide
2021-10-02 Reorganize documentation
2021-10-02 Add firmware upgrade documentation
2021-10-03 Add kicad front and back plate
2021-10-03 Add build action
2021-10-03 checkout submodules for the build action
2021-10-03 install objcopy
2021-10-03 install objcopy++
2021-10-03 check doc links, add badge
2021-10-03 fix workflow?
2021-10-03 do not check node markdown files
2021-10-03 use text/html for link checker
2021-10-03 readme badge++
2021-10-03 Add packaging script
2021-10-03 add info about part selection to build guide
2021-10-03 release firmware action
2021-10-03 Add updating manual to releases
2021-10-03 Fix packaging
2021-10-03 Add firmware flashing instructions to the build guide
2021-10-05 Add clear preset option and first TRS a/b selection code
    Closes #48.
2021-10-05 Tiny cleanup
2021-10-06 hopefully a more extensible settings format for now
2021-10-07 Reorganize code into modules
    Closes #64
2021-10-07 Fix serializing bug
2021-10-07 Add note about upcoming firmware compatibility issues
2021-10-07 Be more robust when reading corrupt (or wrong-version) saved presets
2021-10-07 Add video about SMD soldering
2021-10-10 Add time series badge
2021-10-10 Automatic seriesci upload
2021-10-10 fix ci
2021-10-17 Reference IBOM in manual and readme
2021-10-17 Fix second ibom link, too
2021-10-17 Add notes to iboms
2021-10-18 Ignore HTML files in GitHub's language detection
2021-10-23 Use simple-flash-store for settings
2021-10-23 Fix half-open assembly instructions
2021-10-23 Add option to clear preset when flash is corrupt
2021-10-23 fix cfg(feature=...)
2021-10-23 Fix crash when writing odd data lengths
2021-10-23 Fix bug in deserializing presets
2021-10-23 Fix bug in serializing presets
2021-10-23 Add debugprints for file loading and saving
2021-11-20 Display used/free memory bytes
2021-11-20 Allow failing certificate check for seriesci
    Duh, what a great example of other peoples breaking my build. Anyway,
    seriesci credentials are not that important, if they got lost, damage
    is very very limited. So just ignore the certificate check for now...
2021-11-20 Image link to http version of seriesci. Oh boi
2021-11-21 Add "Clear single preset" menu entry
2021-11-21 Improve TRS a/b readability
2021-11-21 Display current preset size
2021-11-30 Improve contrast and zoom on rev01 fix images
2021-11-30 rotate rev01 fix photo to match schematic images
2021-12-01 Ignore failing seriesci links in link checker...
2021-12-01 I hate JSON
2021-12-01 Could people *please* document their stuff properly?
2021-12-06 Improve rev01 fix guide
2022-01-04 make render.sh executable, add Xvfb and xdotool
2022-01-04 Install gs, upload artifact
2022-01-04 ghostscript...
2022-01-04 Hopefully this works now?
2022-01-04 o boi
2022-01-04 experiment with adding releases to a different repo
2022-01-04 Automatic kicad schematic and board view export
2022-01-04 Disable the technical drawing workflow
    It was moved to github.com/Windfisch/midikraken-hardware
2022-01-06 Fix broken schematic
2022-01-06 Add git revision to generated schematic export
    Implements #75
2022-02-06 Add instruction for JP14 to build guide
2022-03-02 README: improve semantic connection between link text and link
2022-03-03 gitignore: allow udev rule files
2022-03-03 firmware: add udev rule for bootloader usb device permissions
2022-03-19 Debug macros instead of writeln!
2022-03-19 Partially converted to rtic 1, does not compile yet
2022-03-19 Only locks are missing
2022-03-19 It compiles
2022-03-19 Fix compile error with debugprint_verbose
2022-03-19 Fix crash at startup. Finish migration to RTIC 1
2022-03-19 Move initialization down a bit
2022-03-19 Change debug print settings
2022-03-20 Factor out some code into modules
2022-03-20 Refactor a tiny bit more
2022-03-22 cargo update
2022-03-22 Replace generic-array with const generics (finally!)
    Closes #49.
2022-03-22 Update toolchain
2022-03-22 Clean up Cargo.toml
2022-03-22 rustfmt
2022-03-27 Factor out gui task and user input; still WIP
2022-03-27 resource-less debug print. still WIP
2022-03-27 Refactoring done, compiles again. untested
2022-03-27 Works again \o/
2022-03-27 Add self test menu stub
2022-03-27 Use GUI menu stack instead of manually managing "back" entries
    Closes #92.
2022-03-27 use heapless::{Vec, String}
2022-03-27 Get rid of `tx` resource
2022-03-27 fix warnings
2022-03-27 cargo fmt
2022-03-28 simplify locking for event forwarding code
2022-03-29 factor out route_message_internally()
2022-03-29 make debugpanic independent of debug_verbose again
2022-03-29 Add self test feature
    Closes #84
2022-03-31 Display version number in settings menu
2022-03-31 Add CHANGELOG and adapt release pipeline
2022-03-31 Bump cargo.toml version
2022-03-31 cargo.lock
2022-03-31 Fix changelog
2022-04-03 Allow inverting the encoder direction via settings
    Closes #78
2022-04-03 Load and store TRS a/b select
    Closes #70, #34
2022-04-03 Fix bug in serialization of TRS a/b select
2022-04-03 Indicate routing matrix direction
    Closes #68
2022-04-03 Release firmware 0.2.1
2022-04-07 Convert din5_pcb.kicad_pcb to KiCAD 6 format
2022-07-11 Fix timing/missing data issue when the queues run full.
    Fixes #93.
    Essentially, when an UART queue becomes full, the USB task stops sending.
    When the queue becomes non-full again, however, it did not start sending again,
    until another USB interrupt was received for an unrelated reason. This caused
    timing issues that break flashing firmwares via sysex, for example.
2022-07-11 More efficient "queue available" notification:
    Only notify the sender tasks when
    1. It has previously failed to add data to the queue
    2. The queue now became completely empty
2022-07-18 Bump version to 0.2.2

Notices in the files:
hardware/din5_pcb/din5_pcb.kicad_pcb:
the terms of the CERN-OHL-S v2 (https://ohwr.org/cern_ohl_s_v2.txt).
This source describes Open Hardware and is licensed under the CERN-OHL-S v2.
Copyright (c) 2021 Florian Jung.
You may redistribute and modify this source and make products using it under
As per CERN-OHL-S v2 section 4, should You produce hardware based on this
