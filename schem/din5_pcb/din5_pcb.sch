File: schem/din5_pcb/din5_pcb.sch (KiCad schematic (older format))
At the start: 10 parts, among them J101 2x3 female, J102 2x3 female, U101 74HCT245, U102 74HC165, U103 74HC595, U104 74HC595

Commit message: din5 pcb ++
Parts:
- removed JP102: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm, symbol Jumper:SolderJumper_2_Open
- removed U104: 74HC595, Package_DIP:DIP-16_W7.62mm, symbol 74xx:74HC595
- added C101, C102: 100n, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added D101, D102, D103: LED, LED_THT:LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm, symbol Device:LED
- added D104: LED, LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z6.0mm, symbol Device:LED
- added D201, D202, D203, D204: yellow, LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z6.0mm, symbol Device:LED
- added J1: Conn_01x03_Male, Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical, symbol Connector:Conn_01x03_Male
- added J101, J102, J103, J104, J201, J202, J203, J204: DIN-5_180degree, footprints:DIN5, symbol Connector:DIN-5_180degree
- added JP1, JP10, JP11, JP12, JP13, JP2, JP3, JP4, JP5, JP6, JP7, JP8: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm, symbol Jumper:SolderJumper_2_Open
- added JP14: SolderJumper_3_Bridged12, Jumper:SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm, symbol Jumper:SolderJumper_3_Bridged12
- added R101, R102, R103, R104, R107, R108, R111, R112, R205, R206, R207, R208, R209, R210, R211, R212: 220, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added R105, R106, R109, R110, R201, R202, R203, R204: 1k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added U101, U102: HCPL-2630, Package_DIP:DIP-8_W7.62mm, symbol Isolator:HCPL-2630
- JP9: renamed from JP101; footprint Jumper:SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm -> Jumper:SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
- renumbered A101 to A1, J101 to J2, J102 to J3, R101 to R1, U101 to U1, U103 to U2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
Connections:
- net labels added: +3V3, VCC, in0, in1, in2, in3, out0, out1, out2, out3
- wire segments 98 -> 131
- no-connect marks 6 -> 28
Other:
- moved on the sheet: A1, J2, J3, JP9, R1, U1, U2, U3

Commit message: din5 board layout
Parts:
- removed JP10, JP11, JP12, JP13, JP5, JP6, JP7, JP8: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm, symbol Jumper:SolderJumper_2_Open
- added JP5, JP6, JP7, JP8: SolderJumper_3_Open, Jumper:SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm, symbol Jumper:SolderJumper_3_Open
- renumbered D103 to D102, D102 to D103
Connections:
- net +5V: no longer JP9.1 (A)
- net VCC: now also JP9.1 (A)
- net out0: now also JP5.2 (C)
- net out1: now also JP6.2 (C)
- net out2: now also JP7.2 (C)
- net out3: now also JP8.2 (C)
- net at U1.12 (B6): now also JP5.3 (B)
- net at U1.13 (B5): now also JP6.3 (B)
- net at U1.14 (B4): now also JP7.3 (B)
- net at U1.15 (B3): now also JP8.3 (B)
- net PB9: now reaches A1.PB9, U1.5 (A3)
- net PB9: now also JP8.1 (A)
- net PB8: now reaches A1.PB8, U1.6 (A4)
- net PB8: now also JP7.1 (A)
- net PB7: now reaches A1.PB7, U1.7 (A5)
- net PB7: now also JP6.1 (A)
- net PB6: now reaches A1.PB6, U1.8 (A6)
- net PB6: now also JP5.1 (A)
Changed lines of the file:
@@
-	1    0    0    -1
-$EndComp
-$Comp
-L power:+5V #PWR05
-U 1 1 60B5C9B3
-P 3450 2450
-F 0 "#PWR05" H 3450 2300 50  0001 C CNN
-F 1 "+5V" H 3465 2623 50  0000 C CNN
-F 2 "" H 3450 2450 50  0001 C CNN
-F 3 "" H 3450 2450 50  0001 C CNN
-	1    3450 2450
 	1    0    0    -1
 $EndComp
@@
 Text GLabel 7950 1575 2    50   Input ~ 0
 out3
-Text GLabel 5275 1775 2    50   Input ~ 0
+Text GLabel 5250 1975 1    50   Input ~ 0
 out0
-Text GLabel 5275 1575 2    50   Input ~ 0
+Text GLabel 5850 1775 1    50   Input ~ 0
 out2
-Text GLabel 5275 1675 2    50   Input ~ 0
+Text GLabel 5550 1875 1    50   Input ~ 0
 out1
-Text GLabel 5275 1475 2    50   Input ~ 0
+Text GLabel 6150 1675 1    50   Input ~ 0
 out3
 Wire Wire Line
@@
 in3
 $Comp
-L Jumper:SolderJumper_2_Open JP10
-U 1 1 60EC043C
-P 5125 1475
-F 0 "JP10" H 5575 1475 50  0000 C CNN
-F 1 "SolderJumper_2_Open" H 5125 1589 50  0001 C CNN
-F 2 "Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm" H 5125 1475 50  0001 C CNN
-F 3 "~" H 5125 1475 50  0001 C CNN
-	1    5125 1475
-	1    0    0    -1
-$EndComp
-$Comp
-L Jumper:SolderJumper_2_Open JP11
-U 1 1 60EC5D98
-P 5125 1575
-F 0 "JP11" H 5575 1575 50  0000 C CNN
-F 1 "SolderJumper_2_Open" H 5125 1689 50  0001 C CNN
-F 2 "Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm" H 5125 1575 50  0001 C CNN
-F 3 "~" H 5125 1575 50  0001 C CNN
-	1    5125 1575
-	1    0    0    -1
-$EndComp
-$Comp
-L Jumper:SolderJumper_2_Open JP12
-U 1 1 60EC62BD
-P 5125 1675
-F 0 "JP12" H 5575 1675 50  0000 C CNN
-F 1 "SolderJumper_2_Open" H 5125 1789 50  0001 C CNN
-F 2 "Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm" H 5125 1675 50  0001 C CNN
-F 3 "~" H 5125 1675 50  0001 C CNN
-	1    5125 1675
-	1    0    0    -1
-$EndComp
-$Comp
-L Jumper:SolderJumper_2_Open JP13
-U 1 1 60EC68B9
-P 5125 1775
-F 0 "JP13" H 5575 1775 50  0000 C CNN
-F 1 "SolderJumper_2_Open" H 5125 1889 50  0001 C CNN
-F 2 "Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm" H 5125 1775 50  0001 C CNN
-F 3 "~" H 5125 1775 50  0001 C CNN
-	1    5125 1775
-	1    0    0    -1
-$EndComp
-$Comp
 L bluepill:BluePill A1
 U 1 1 60DBE39E
@@
 	1    0    0    -1
 $EndComp
-Text GLabel 3025 1025 2    50   Input ~ 0
-out0
-Text GLabel 3025 825  2    50   Input ~ 0
-out2
-Text GLabel 3025 925  2    50   Input ~ 0
-out1
-Text GLabel 3025 725  2    50   Input ~ 0
-out3
-$Comp
-L Jumper:SolderJumper_2_Open JP5
-U 1 1 61184BC2
-P 2875 725
-F 0 "JP5" H 3325 725 50  0000 C CNN
-F 1 "SolderJumper_2_Open" H 2875 839 50  0001 C CNN
-F 2 "Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm" H 2875 725 50  0001 C CNN
-F 3 "~" H 2875 725 50  0001 C CNN
-	1    2875 725
-	1    0    0    -1
-$EndComp
-$Comp
-L Jumper:SolderJumper_2_Open JP6
-U 1 1 61184BCC
-P 2875 825
-F 0 "JP6" H 3325 825 50  0000 C CNN
-F 1 "SolderJumper_2_Open" H 2875 939 50  0001 C CNN
-F 2 "Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm" H 2875 825 50  0001 C CNN
-F 3 "~" H 2875 825 50  0001 C CNN
-	1    2875 825
-	1    0    0    -1
-$EndComp
-$Comp
-L Jumper:SolderJumper_2_Open JP7
-U 1 1 61184BD6
-P 2875 925
-F 0 "JP7" H 3325 925 50  0000 C CNN
-F 1 "SolderJumper_2_Open" H 2875 1039 50  0001 C CNN
-F 2 "Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm" H 2875 925 50  0001 C CNN
-F 3 "~" H 2875 925 50  0001 C CNN
-	1    2875 925
-	1    0    0    -1
-$EndComp
-$Comp
-L Jumper:SolderJumper_2_Open JP8
-U 1 1 61184BE0
-P 2875 1025
-F 0 "JP8" H 3325 1025 50  0000 C CNN
-F 1 "SolderJumper_2_Open" H 2875 1139 50  0001 C CNN
-F 2 "Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm" H 2875 1025 50  0001 C CNN
-F 3 "~" H 2875 1025 50  0001 C CNN
-	1    2875 1025
-	1    0    0    -1
-$EndComp
+Text GLabel 2725 1025 2    50   Input ~ 0
+PB6
+Text GLabel 2725 825  2    50   Input ~ 0
+PB8
+Text GLabel 2725 925  2    50   Input ~ 0
+PB7
+Text GLabel 2725 725  2    50   Input ~ 0
+PB9
 Wire Wire Line
 	2725 725  2375 725
@@
 $EndComp
 $Comp
-L Device:LED D103
+L Device:LED D102
 U 1 1 60D3D13A
 P 3500 4075
-AR Path="/60D3D13A" Ref="D103"  Part="1"
+AR Path="/60D3D13A" Ref="D102"  Part="1"
 AR Path="/60B37C5E/60D3D13A" Ref="D?"  Part="1"
 AR Path="/60B6A74D/60D3D13A" Ref="D?"  Part="1"
-F 0 "D103" V 3539 3957 50  0000 R CNN
+F 0 "D102" V 3539 3957 50  0000 R CNN
 F 1 "LED" V 3448 3957 50  0000 R CNN
 F 2 "LED_THT:LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm" H 3500 4075 50  0001 C CNN
@@
 	2450 6450 2450 6525
 $Comp
-L Device:LED D102
+L Device:LED D103
 U 1 1 60D3D18D
 P 2650 6000
-AR Path="/60D3D18D" Ref="D102"  Part="1"
+AR Path="/60D3D18D" Ref="D103"  Part="1"
 AR Path="/60B37C5E/60D3D18D" Ref="D?"  Part="1"
 AR Path="/60B6A74D/60D3D18D" Ref="D?"  Part="1"
-F 0 "D102" V 2689 5882 50  0000 R CNN
+F 0 "D103" V 2689 5882 50  0000 R CNN
 F 1 "LED" V 2598 5882 50  0000 R CNN
 F 2 "LED_THT:LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm" H 2650 6000 50  0001 C CNN
@@
 	1    0    0    -1
 $EndComp
+$Comp
+L Jumper:SolderJumper_3_Open JP5
+U 1 1 60CA9C1B
+P 5100 1975
+F 0 "JP5" V 4975 1750 50  0000 L CNN
+F 1 "SolderJumper_3_Open" V 5055 2042 50  0001 L CNN
+F 2 "Jumper:SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm" H 5100 1975 50  0001 C CNN
+F 3 "~" H 5100 1975 50  0001 C CNN
+	1    5100 1975
+	0    -1   -1   0
+$EndComp
+Wire Wire Line
+	5100 1775 4975 1775
+$Comp
+L Jumper:SolderJumper_3_Open JP6
+U 1 1 60CD46F4
+P 5400 1875
+F 0 "JP6" V 5275 1650 50  0000 L CNN
+F 1 "SolderJumper_3_Open" V 5355 1942 50  0001 L CNN
+F 2 "Jumper:SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm" H 5400 1875 50  0001 C CNN
+F 3 "~" H 5400 1875 50  0001 C CNN
+	1    5400 1875
+	0    -1   -1   0
+$EndComp
+Wire Wire Line
+	5400 1675 4975 1675
+Wire Wire Line
+	5700 1575 4975 1575
+$Comp
+L Jumper:SolderJumper_3_Open JP8
+U 1 1 60CE9EC4
+P 6000 1675
+F 0 "JP8" V 5875 1450 50  0000 L CNN
+F 1 "SolderJumper_3_Open" V 5955 1742 50  0001 L CNN
+F 2 "Jumper:SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm" H 6000 1675 50  0001 C CNN
+F 3 "~" H 6000 1675 50  0001 C CNN
+	1    6000 1675
+	0    -1   -1   0
+$EndComp
+Wire Wire Line
+	6000 1475 4975 1475
+$Comp
+L Jumper:SolderJumper_3_Open JP7
+U 1 1 60CDFF27
+P 5700 1775
+F 0 "JP7" V 5575 1550 50  0000 L CNN
+F 1 "SolderJumper_3_Open" V 5655 1842 50  0001 L CNN
+F 2 "Jumper:SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm" H 5700 1775 50  0001 C CNN
+F 3 "~" H 5700 1775 50  0001 C CNN
+	1    5700 1775
+	0    -1   -1   0
+$EndComp
+Text GLabel 5100 2175 3    50   Input ~ 0
+PB6
+Text GLabel 5400 2075 3    50   Input ~ 0
+PB7
+Text GLabel 5700 1975 3    50   Input ~ 0
+PB8
+Text GLabel 6000 1875 3    50   Input ~ 0
+PB9
+$Comp
+L power:VCC #PWR?
+U 1 1 60D4324F
+P 3450 2450
+F 0 "#PWR?" H 3450 2300 50  0001 C CNN
+F 1 "VCC" H 3465 2623 50  0000 C CNN
+F 2 "" H 3450 2450 50  0001 C CNN
+F 3 "" H 3450 2450 50  0001 C CNN
+	1    3450 2450
+	1    0    0    -1
+$EndComp

Commit message: Re-order parts on din5_pcb
Parts:
- A1: footprint footprints:BLUEPILL -> footprints:BLUEPILL-blackpill
- J1: footprint Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical -> Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Horizontal
- JP14, JP9: footprint Jumper:SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm -> Jumper:SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
Changed lines of the file:
@@
 F 0 "JP9" V 3404 2718 50  0000 L CNN
 F 1 "SolderJumper_3_Bridged12" V 3800 1550 50  0000 L CNN
-F 2 "Jumper:SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm" H 3450 2650 50  0001 C CNN
+F 2 "Jumper:SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm" H 3450 2650 50  0001 C CNN
 F 3 "~" H 3450 2650 50  0001 C CNN
 	1    3450 2650
@@
 F 0 "J1" V 2712 1662 50  0000 R CNN
 F 1 "Conn_01x03_Male" V 2803 1662 50  0000 R CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical" H 2650 1850 50  0001 C CNN
+F 2 "Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Horizontal" H 2650 1850 50  0001 C CNN
 F 3 "~" H 2650 1850 50  0001 C CNN
 	1    2650 1850
@@
 F 0 "A1" H 1400 950 60  0000 C CNN
 F 1 "BluePill" H 1400 825 60  0000 C CNN
-F 2 "footprints:BLUEPILL" H 1450 2675 60  0001 C CNN
+F 2 "footprints:BLUEPILL-blackpill" H 1450 2675 60  0001 C CNN
 F 3 "" H 1450 2675 60  0001 C CNN
 	1    1550 1925
@@
 F 0 "JP14" H 8425 6188 50  0000 C CNN
 F 1 "SolderJumper_3_Bridged12" H 8425 6279 50  0000 C CNN
-F 2 "Jumper:SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm" H 8425 6075 50  0001 C CNN
+F 2 "Jumper:SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm" H 8425 6075 50  0001 C CNN
 F 3 "~" H 8425 6075 50  0001 C CNN
 	1    8425 6075
@@
 PB9
 $Comp
-L power:VCC #PWR?
+L power:VCC #PWR0109
 U 1 1 60D4324F
 P 3450 2450
-F 0 "#PWR?" H 3450 2300 50  0001 C CNN
+F 0 "#PWR0109" H 3450 2300 50  0001 C CNN
 F 1 "VCC" H 3465 2623 50  0000 C CNN
 F 2 "" H 3450 2450 50  0001 C CNN

Commit message: Come layout considerations
Parts:
- added J111, J112, J113, J114, J211, J212, J213, J214: do not equip, footprints:DIN5, symbol Connector:DIN-5_180degree
- added J4, J5: USB_B_Micro, symbol Connector:USB_B_Micro
- added J6, J7: Conn_02x02_Counter_Clockwise, symbol Connector_Generic:Conn_02x02_Counter_Clockwise
- D104: footprint LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z6.0mm -> LED_THT:LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
Connections:
- net GND: now also J211.2, J212.2, J213.2, J214.2, J4.5 (GND), J5.5 (GND), J6.3 (Pin_3), J6.4 (Pin_4), J7.2 (Pin_2)
- net VCC: now also J4.1 (VBUS), J5.1 (VBUS), J6.1 (Pin_1), J6.2 (Pin_2), J7.1 (Pin_1)
- net at J101.5, U101.2 (C1): now also J111.5
- net at J102.5, U101.3 (C2): now also J112.4, J112.5
- net at J101.4, R101.2: now also J111.4
- net at J103.5, U102.2 (C1): now also J113.5
- net at J104.5, U102.3 (C2): now also J114.4, J114.5
- net at J103.4, R103.2: now also J113.4
- net at J204.4, R212.1: now also J214.4
- net at J204.5, R208.1: now also J214.5
- net at J203.4, R211.1: now also J213.4
- net at J203.5, R207.1: now also J213.5
- net at J202.4, R210.1: now also J212.4
- net at J202.5, R206.1: now also J212.5
- net at J201.4, R209.1: now also J211.4
- net at J201.5, R205.1: now also J211.5
- net USB_DM: now reaches A1.PA11
- net USB_DM: now also J4.2 (D-), J7.3 (Pin_3)
- net USB_DP: now reaches A1.PA12
- net USB_DP: now also J4.3 (D+), J7.4 (Pin_4)
- net USB_ID: now reaches A1.PA8
- net USB_ID: now also J4.4 (ID)
- no-connect marks 28 -> 45
Other:
- note added: "TODO: pinouts richtig drehen..."
- note added: "USB-OTG only!"
- note added: "power only!"
- note added: "to eurorack USB-A\nsocket for host"
- moved on the sheet: C101, C102, D101, D102, D103, D104, D201, D202, D203, D204, J1, J101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
